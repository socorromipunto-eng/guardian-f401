# Keil uVision project Guardian-F401.uvprojx, settings and files
target Guardian-F401-Structural-Review (6240000::V6.24::ARMCLANG)
  device: STM32F401CDUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x0000C000) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Guardian-F401
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F401xE,USE_HAL_DRIVER
  c include: GuardianF401\Drivers\CMSIS\Device\ST\STM32F4xx\Include;GuardianF401\Drivers\CMSIS\Include;..\Acquisition\Inc;..\App\Inc;..\Control\Inc;..\DSP\Inc;..\Firmware\Inc;..\Health\Inc;..\NodeLink\Inc;..\Platform\Inc;..\Platform\STM32F401\Inc;..\Protocol\Inc;..\Security\Inc;..\Telemetry\Inc;GuardianF401\Inc;GuardianF401\Drivers\STM32F4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0xC000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Startup and System
    GuardianF401/MDK-ARM/: startup_stm32f401xe.s
    GuardianF401/Src/: system_stm32f4xx.c
  group Guardian Entry
    ../MDK-ARM/Templates/: main_guardian.c
  group Guardian Application
    ../App/Src/: guardian_device_service.c guardian_firmware_app.c
  group Guardian Acquisition
    ../Acquisition/Src/: guardian_acquisition.c
    ../Platform/STM32F401/Src/: stm32f401_acquisition.c stm32f401_acquisition_irq.c
  group Guardian Control and DSP
    ../Control/Src/: guardian_control.c
    ../DSP/Src/: guardian_dsp.c
  group Guardian Health and Lifecycle
    ../Health/Src/: guardian_health.c
    ../Firmware/Src/: guardian_firmware_lifecycle.c
  group Guardian Platform
    ../Platform/Src/: guardian_embedded_link.c
    ../Platform/STM32F401/Src/: guardian_stm32f401_preflight.c stm32f401_uart2.c stm32f401_uart2_irq.c
  group Guardian NodeLink
    ../NodeLink/Src/: guardian_node_link.c guardian_node_link_auth.c guardian_node_link_semantic.c
    ../App/Src/: guardian_f401_nodelink_adapter.c
  group Guardian Protocol
    ../Protocol/Src/: guardian_parser.c guardian_protocol.c
  group Guardian Security
    ../Security/Src/: guardian_crypto.c guardian_security.c
  group Guardian Telemetry
    ../Telemetry/Src/: guardian_telemetry.c
  group NodeLink Persistence R3C-E
    ../NodeLink/Src/: guardian_node_link_freshness.c guardian_node_link_freshness_persistence.c guardian_node_link_freshness_persistence_backend.c guardian_node_link_freshness_persistence_codec.c guardian_node_link_freshness_persistence_stm32f401.c guardian_node_link_rollback_anchor.c
  group STM32 HAL Flash R3C-E
    GuardianF401/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
